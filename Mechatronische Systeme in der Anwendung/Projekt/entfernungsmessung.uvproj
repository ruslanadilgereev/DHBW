# Keil uVision project entfernungsmessung.uvproj, settings and files
target Target 1 (MCS-51)
  device: XC886CLM-8FF Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF5FF) IROM(0-0x5FFF) IROM2(0xA000-0xBFFF) CLOCK(24000000) MODP2
  output: entfernungsmessung +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: onewire.c DIP204_XC886.c Timer.c
